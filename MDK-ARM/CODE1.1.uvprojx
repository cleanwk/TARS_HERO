# Keil uVision project CODE1.1.uvprojx, settings and files
target CODE1.1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Infantry +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx,USE_HAL_DRIVER,STM32F427xx,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;  ../Drivers/CMSIS/Include;  .\user;  ..\DSP_LIB\Include;  ..\DSP_LIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User
    ../Src/: main.c gpio.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group bsp
    ./user/: bsp_can.c bsp_can.h bsp_uart.c bsp_uart.h
  group chassic
    ./user/: chassic.c chassic.h
  group user_tim
    ./user/: user_tim.c
  group gimbal
    ./user/: task_gimbal.c task_gimbal.h
  group DSP_LIB
    ../DSP_LIB/: arm_cortexM4lf_math.lib
  group shoot
    ./user/: shoot.c blurry_pid.c blurry_pid.H
  group JY901
    ./user/: JY901.C JY901.H
  group system
    ./user/: system.c system.h
  group Vision
    ./user/: shoot.h vision.c vision.h
  group Calculate
    ./user/: Calculate.c Calculate.h
  group LED
    ./user/: LED.c LED.h
  group magazine
    ./user/: magazine.c magazine.h
  group revolver
    ./user/: revolver.c revolver.h
software components: CMSIS:CORE 4.3.0
